# Keil uVision project Screen Controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Screen Controller +hex
  c flags: Optimize=8 SizeSpeed=1
  group app
    ../src/app/: ParaDefine.H HMI.c application.c
  group srv
    ../src/srv/: crc.c crc.h fifo.c fifo.h uartNetwork.c uartNetwork.h parMap.c parMap.h
  group drv
    ../src/drv/: isr.c isr.h STARTUP.A51 STC8.H timer.c timer.h uartDrv.c UARTDRV.H 19296p1.C
  group main
    ../src/main/: main.c task.c task.h
