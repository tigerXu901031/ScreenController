# Keil uVision project doorScreen.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: doorScreen
  c flags: Optimize=8 SizeSpeed=1
  group drv
    ../src/drv/: 19296p1.C isr.c uartDrv.c isr.h STARTUP.A51 STC8.H uartDrv.h
  group srv
    ../src/srv/: fifo.c uartNetwork.c fifo.h uartNetwork.h
